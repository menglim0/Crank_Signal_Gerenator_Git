# Keil uVision project song370.uvprojx, settings and files
target song370 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: BrakeDetection +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Libraries;.\Libraries\inc;.\FreeRTOS\include;.\FreeRTOS\portable;.\User;.\FreeRTOS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Libraries/: core_cm3.c
    ./Startup/: startup_stm32f10x_hd.s
  group FreeRTOS
    ./FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/: heap_2.c port.c
  group Libraries
    ./Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_rtc.c
    ./Libraries/: system_stm32f10x.c
  group user
    ./User/: main.c My_InitTask.c vios.c
